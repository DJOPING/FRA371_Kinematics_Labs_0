Commit message: haha

File: my_robot/robot.urdf (robot description, URDF)
Before this commit: robot Scara_PRRR, 5 links, 4 joints
Links:
- removed link P1-E
Joints:
- removed joint R3
